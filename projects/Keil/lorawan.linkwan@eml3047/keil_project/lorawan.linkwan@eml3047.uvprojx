# Keil uVision project lorawan.linkwan@eml3047.uvprojx, settings and files
target lorawan.linkwan@eml3047 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lorawan.linkwan@eml3047
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\platform\mcu\stm32l475\B-L475E-IOT01.sct
  group board_eml3047
    ../../../.././board/eml3047/: - board.c
    ../../../.././board/eml3047/../../device/lora/eml3047_lrwan/: eml3047.c
    ../../../.././board/eml3047/../../device/lora/sx1276/: sx1276.c
    ../../../.././board/eml3047/src/: debug.c eml3047_hw.c eml3047_it.c hw_gpio.c hw_rtc.c hw_spi.c lorawan_port.c vcom.c
  group kernel_init
    ../../../.././kernel/init/: aos_init.c
  group log
    ../../../.././utility/log/: log.c
  group linkwan
    ../../../.././example/lorawan/linkwan/: linkwan.c
  group kv
    ../../../.././kernel/modules/fs/kv/: kvmgr.c
  group armv6m
    ../../../../././platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group stm32l071kb
    ../../../../././platform/mcu/stm32l0xx/stm32l071kb/../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_adc.c stm32l0xx_ll_gpio.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_usart.c
    ../../../../././platform/mcu/stm32l0xx/stm32l071kb/../aos/: soc_impl.c
    ../../../../././platform/mcu/stm32l0xx/stm32l071kb/../hal/: flash.c
    ../../../../././platform/mcu/stm32l0xx/stm32l071kb/../src/STM32L071KB/runapp/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
    ../../../../././platform/mcu/stm32l0xx/stm32l071kb/../src/STM32L071KB/: startup_stm32l071xx_armcc.s
  group lorawan
    ../../../.././kernel/protocols/lorawan/linkwan/: linkwan.c
    ../../../.././kernel/protocols/lorawan/linkwan/region/: RegionCN470A.c
    ../../../.././kernel/protocols/lorawan/lora/mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../.././kernel/protocols/lorawan/lora/mac/region/: Region.c RegionCommon.c
    ../../../.././kernel/protocols/lorawan/lora/system/crypto/: aes.c cmac.c
    ../../../.././kernel/protocols/lorawan/lora/system/: delay.c low_power.c timeServer.c utilities.c
  group rhino
    ../../../.././kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../.././kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group vcall
    ../../../.././kernel/vcall/aos/: aos_rhino.c
